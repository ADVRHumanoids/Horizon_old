Commit message: updated model to better match coman+ and played with demo

File: configs/urdf/roped_template.urdf (robot description, URDF)
Before this commit: robot roped_template, 15 links, 14 joints
Links:
- link Waist: mass 69.0 -> 40.0
